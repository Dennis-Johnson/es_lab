		AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
		
Reset_Handler
	LDR R0,=ARR
	LDR R1,=SRC
	MOV R2,#N
CP LDR R3,[R0],#4
	STR R3,[R1],#4
	SUBS R2,#1
	BNE CP
	LDR R0,=SRC
	MOV R2,#0
UP MOV R5,R0
	LDR R3,[R0]
	LDR R8,[R0]
	ADD R6,R2,#1
	ADD R1,R0,#4
UP1 LDR R4,[R1]
	CMP R4,R8
	MOVCC R5,R1
	MOVCC R8,R4
	ADD R6,#1
	ADD R1,#4
	CMP R6,#N
	BCC UP1
	STR R8,[R0]
	STR R3,[R5]
	ADD R0,#4
	ADD R2,#1
	CMP R2,#(N-1)
	BCC UP
STOP B STOP
ARR DCD 2,3,1,9,7,4,5
N EQU 7
	AREA MYDATA,DATA,READWRITE
SRC DCD 0
	END
	