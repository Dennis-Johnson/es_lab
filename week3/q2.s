		AREA RESET,DATA,READONLY
		EXPORT __Vectors

__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =N1
	LDR R1, =N2
	LDR R2, [R0]
	LDR R3, [R1]
	MOV R4, #0
	LDR R5, =DST
up	CMP R2, R3
	BCC store
	SUB R2, R3
	ADD R4, #1
	B up

store STR R4,[R5],#4
	  STR R2,[R5]
STOP
	B STOP
N1 DCD 0X00000009
N2 DCD 0X00000004
	AREA data,DATA,READWRITE
DST DCD 0x00000000
	END